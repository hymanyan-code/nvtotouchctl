# Keil uVision project TouchControlPad.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: M0518LD2AE Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.26
  cpu: IRAM(0x20000000,0x2000) IROM(0x00000000,0x11000) CPUTYPE("Cortex-M0") CLOCK(12000000)
  output: TouchControlPad +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\Core;..\System;..\StdDriver\inc;..\OS;..\Hal;..\Modbus\port;..\Modbus\modbus\include;..\Modbus\modbus\rtu;..\MT
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x11000
  memory RVCT9: RAM 0x20000000 size 0x2000
  link misc: --map --first='startup_M0518.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group core
    ../Core/: core_cm0.h core_cmFunc.h core_cmInstr.h
  group System
    ../System/: M0518.h startup_M0518.s system_M0518.c system_M0518.h
  group User
    ../User/: main.c
  group StdDriver
    ../StdDriver/src/: adc.c bpwm.c clk.c fmc.c gpio.c i2c.c pwm.c retarget.c spi.c sys.c timer.c uart.c wdt.c wwdt.c
  group OS
    ../OS/: cpu.c OS_System.c
  group HAL
    ../Hal/: hal_led.c hal_task.c hal_timer.c hal_beep.c hal_io.c hal_rs485.c hal_adc.c hal_stepper.c
  group MODBUS
    ../Modbus/port/: portevent.c portserial.c porttimer.c
    ../Modbus/modbus/functions/: mbfuncholding.c mbutils.c
    ../Modbus/modbus/rtu/: mbcrc.c mbrtu.c
    ../Modbus/modbus/: mb.c
  group MT
    ../MT/: mt_modbus.c mt_task.c
